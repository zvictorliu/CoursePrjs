# Keil uVision project Demo.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2119 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=68,191,188
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Objects\Demo.sct
  group Source Group 1
    ./Source/: Startup.s
  group Header Group
    ./Source/: LPC2294.h config.h myI2C.h myLCD.h
  group Source Group
    ./Source/: myI2C.c myLCD.c main.c
  group can
    ./Source/can/: CanApp.c CanApp.h CanFunc.c CanFunc.h CanReg.h Custom.h IncludeCan.H
