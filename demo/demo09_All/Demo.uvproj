# Keil uVision project Demo.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2119 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c misc: --diag_suppress=2532
  c include: .\app;.\arm;.\ucosii;.\source;.\can
  asm misc: --diag_suppress=A1608W
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group app
    ./App/: bsp.c main.c
    ./app/: startup.s os_cfg.h
  group arm
    ./arm/: os_cpu_a.s os_cpu_c.c os_int_a.s os_cpu.h
  group ucosii
    ./ucosii/: Includes.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c ucos_ii.h
  group source
    ./source/: config.h LPC2294.h myI2C.c myI2C.h myLCD.c myLCD.h
  group can
    ./can/: CanApp.c CanApp.h CanFunc.c CanFunc.h CanReg.h Custom.h IncludeCan.H
